/*     
LCD5110
    CLK  - Pin 8 
    DIN  - Pin 9 
    DC   - Pin 10  
    RST  - Pin 11  
    CE   - Pin 12

*/

#include <LCD5110_Basic.h>
#include <Wire.h> 
#include <BMP085.h>
#include <DHT.h>
#include <stdio.h>
#include <DS1302.h>
#include <MsTimer2.h>

#define DHTPIN 2    //датчик влажности ко 2 пину
#define DHTTYPE DHT11

BMP085 dps = BMP085();    //vcc +3.3v; SDA->A4; SCL->A5 барометр

LCD5110 myGLCD(8,9,10,11,12);

DHT dht(DHTPIN, DHTTYPE);  //модуль часов

extern uint8_t SmallFont[];
extern uint8_t MediumNumbers[];
extern uint8_t BigNumbers[];

long Temperature = 0, Pressure = 0;

int timer01 = 0, timer02 = 0;           // таймер01, 02

long statistic = 0;                    // прошлое давление
float realBaro = 0;                    // реальное давление

//================= Часы ===================================
namespace {

const int kCePin   = 5;  // Chip Enable rst
const int kIoPin   = 6;  // Input/Output  dat
const int kSclkPin = 7;  // Serial Clock clk

DS1302 rtc(kCePin, kIoPin, kSclkPin);

String dayAsString(const Time::Day day) {
    switch (day) {
        case Time::kSunday: return "Sunday";
        case Time::kMonday: return "Monday";
        case Time::kTuesday: return "Tuesday";
        case Time::kWednesday: return "Wednesday";
        case Time::kThursday: return "Thursday";
        case Time::kFriday: return "Friday";
        case Time::kSaturday: return "Saturday";
    }
    return "(unknown day)";
}

void printTime() {
    Time t = rtc.time();
    const String day = dayAsString(t.day);
    char buf[50];
    
    //snprintf(buf, sizeof(buf), "%s %04d-%02d-%02d %02d:%02d:%02d",
    snprintf(buf, sizeof(buf), "%02d:%02d:%02d",
    //  day.c_str(),
    //  t.yr, t.mon, t.date,
      t.hr, t.min, t.sec);

    myGLCD.print(buf, CENTER, 24);
    
    Timer01();    // Запуск таймера01
    Timer02();    // Запуск таймера02
     
    Serial.println(buf);
}
}  // namespace
//=========================================================

void setup() {
  myGLCD.InitLCD(60);  // контрасность LCD  
  dps.init();   
  dht.begin();
  myGLCD.clrScr();

  rtc.writeProtect(false);    //часы
  rtc.halt(false);
//  Time t(2014, 11, 27, 2, 37, 20, Time::kSunday);
//  rtc.time(t);
 
  MsTimer2::set(1000, printTime); // Запуск таймера часов 1сек
  MsTimer2::start();
  
  dps.getPressure(&Pressure);    // Снять показания давления
  statistic = Pressure*0.01;
  
  Serial.begin(9600); 
}

void loop() {

}    

void printBaro() {
    dps.getPressure(&Pressure); 
    myGLCD.setFont(MediumNumbers);
    myGLCD.printNumI(Pressure/133.3, 7, 0);
    myGLCD.setFont(SmallFont);
    realBaro = Pressure*0.01;
    myGLCD.printNumF(float(realBaro), 2, RIGHT, 16);
    myGLCD.print("mm.rt", 44, 10);
   Serial.print("Pressure(mm Hg): "); 
   Serial.print(Pressure/133.3);         //Выводим давление в мм.рт ст
   Serial.print("  Pressure(hPa): "); 
   Serial.println(Pressure*0.01);
   BaroStatistic();                      // Запуск ф-и снятия показаний об из-й давления
}

  
void printTemp() {
    dps.getTemperature(&Temperature);
    float f = Temperature*0.1;            //Отделение дробной части
    int a = f;                            //
    float b = (f - a)/0.1;                //
    myGLCD.setFont(MediumNumbers);
    myGLCD.printNumI(f, LEFT, 37);
    myGLCD.setFont(SmallFont); 
    myGLCD.printNumI(b, 25, 47);          //Вывод дробной части
    myGLCD.print("C", 33, 47);
   Serial.print("Temp: "); 
   Serial.println(Temperature*0.1);       // Температуру в градусах Цельсия
}

void printHumidity() {
    float h = dht.readHumidity();
    myGLCD.setFont(MediumNumbers);
    myGLCD.printNumI(h, 50, 37);
    myGLCD.setFont(SmallFont);
    myGLCD.print("%", RIGHT, 47);   
   Serial.print("Humidity: ");       
   Serial.println(h);                     //Влажность  
}

void Timer01() {                          // Устанавить таймер01 на 3 сек
    timer01++;
    if (timer01 >2 ) {                    // Вывод всех датчиков на экран
        printHumidity();
        printTemp();
        printBaro();
        timer01 = 0;                      // Обнулить таймер01
    }
  //  myGLCD.printNumI(timer01, 1, 16);                   
}

void Timer02() {                          // Устанавить таймер02 на 20 мин (1200сек )
    timer02++;
    if (timer02 >1200 ) {
        statistic = realBaro;
        timer02 = 0;  
    }
//    myGLCD.printNumI(timer02, LEFT, 0);    
}

void BaroStatistic() {
    myGLCD.setFont(SmallFont);
    long baro = Pressure*0.01;
    long result = 0;
  myGLCD.printNumI(statistic, 1, 16); 
    if (baro != statistic) {
          timer02 = 0;                   // обнулить таймер02 при изменениях в давлении
          result = baro - statistic  ;      
    } 
        if (baro > statistic ) {
            myGLCD.print("+", 62, 0);  
            myGLCD.printNumI(result, RIGHT, 0);
        }  
        else if (baro < statistic ) {
            myGLCD.print("-", 62, 0);
            myGLCD.printNumI(result, RIGHT, 0);
        }    
        else if (baro == statistic ) {  
             myGLCD.print(" ", 62, 0);
             myGLCD.printNumI(result, RIGHT, 0); 
            
        }   
}


