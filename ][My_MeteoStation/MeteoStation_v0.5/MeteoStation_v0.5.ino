/*     
LCD5110
    CLK  - Pin 8 
    DIN  - Pin 9 
    DC   - Pin 10  
    RST  - Pin 11  
    CE   - Pin 12
*/

#include <LCD5110_Graph.h>
#include <Wire.h> 
#include <BMP085.h>
#include <DHT.h>
#include <stdio.h>
#include <DS1302.h>
#include <MsTimer2.h>

#define DHTPIN 2    //датчик влажности ко 2 пину
#define DHTTYPE DHT11

#define PLOT_LEN      46 // 46 пикселей - длинна графика
#define STORAGE_TIME  200 // 200*timer01(3сек) = ~10 мин. Период обновления одной точки г-ка. В итоге статистика за ~8ч, (10мин*46пикс=460мин/60сек=7.67ч)

BMP085 dps = BMP085();    //vcc +3.3v; SDA->A4; SCL->A5 барометр

LCD5110 myGLCD(8,9,10,11,12);

DHT dht(DHTPIN, DHTTYPE);  //модуль часов

extern uint8_t SmallFont[];
extern uint8_t MediumNumbers[];
extern uint8_t BigNumbers[];

struct {
  byte temp = 0;  
  byte pres = 0;  
} infoArr[PLOT_LEN];

struct {
  float temp = 0;
  float pres = 0;
  int counter = 0;
} avrg;

void drawCol(int x, int y, int yn); // для гр-ка

void Timer01();
int timer01 = 0;            // таймер 01

long Temperature = 0, Pressure = 0;

//================= Часы ===================================
namespace {

const int kCePin   = 5;  // Chip Enable rst
const int kIoPin   = 6;  // Input/Output  dat
const int kSclkPin = 7;  // Serial Clock clk

DS1302 rtc(kCePin, kIoPin, kSclkPin);

String dayAsString(const Time::Day day) {
    switch (day) {
        case Time::kSunday: return "Sun";
        case Time::kMonday: return "Mon";
        case Time::kTuesday: return "Tue";
        case Time::kWednesday: return "Wed";
        case Time::kThursday: return "Thu";
        case Time::kFriday: return "Fri";
        case Time::kSaturday: return "Sat";
    }
    return "(unknown day)";
}

char buf[50];
const String day;

void printTime() {
    Time t = rtc.time();
    //const String day = dayAsString(t.day);
    day = dayAsString(t.day);
    //char buf[50];
    
    //snprintf(buf, sizeof(buf), "%s %04d-%02d-%02d %02d:%02d:%02d",
    snprintf(buf, sizeof(buf), "%02d:%02d:%02d",
    //  day.c_str(),
    //  t.yr, t.mon, t.date,
      t.hr, t.min, t.sec);
      
    //myGLCD.print(buf, CENTER, 24);
    //myGLCD.print(day.c_str(), 1, 16); 

    Timer01();    // Запуск таймера01
     
    Serial.println(buf);
}
}  // namespace
//=========================================================

void setup() {
  myGLCD.InitLCD(60);  // контрасность LCD  
  dps.init();   
  dht.begin();
//  myGLCD.clrScr();

  rtc.writeProtect(false);    //часы
  rtc.halt(false);            //
//  Time t(2014, 11, 27, 2, 37, 20, Time::kSunday);
//  rtc.time(t);
 
  MsTimer2::set(1000, printTime); // Запуск таймера часов 1сек
  MsTimer2::start();              //
  
  dps.getPressure(&Pressure);    // Снять показания давления
}

void loop() {
//все ф-и запускает Timer01 с интервалом 3 сек
}    

void printBaro() {
    dps.getPressure(&Pressure); 
    myGLCD.setFont(MediumNumbers);
    myGLCD.printNumI(Pressure/133.3, LEFT, 0);
    myGLCD.setFont(SmallFont);
    myGLCD.printNumF(float(Pressure*0.01), 2, RIGHT, 16);
}

void printTemp() {
    dps.getTemperature(&Temperature);
    float f = Temperature*0.1;            //Отделение дробной части
    int a = f;                            //
    float b = (f - a)/0.1;                //
    myGLCD.setFont(MediumNumbers);
    myGLCD.printNumI(f, LEFT, 32);
    myGLCD.setFont(SmallFont); 
    myGLCD.printNumI(b, 25, 40);          //Вывод дробной части
    myGLCD.print("C", 33, 40);
}

void printHumidity() {
    float h = dht.readHumidity();
    myGLCD.setFont(MediumNumbers);
    myGLCD.printNumI(h, 50, 32);
    myGLCD.setFont(SmallFont);
    myGLCD.print("%", RIGHT, 40);     
}

inline void Timer01() {    // Устанавить таймер01 на 3 сек
    timer01++;
    if (timer01 > 2) {                    // Вывод всех датчиков на экран
        myGLCD.clrScr();
        myGLCD.print(buf, CENTER, 24);
        myGLCD.print(day.c_str(), 1, 16); 
        printHumidity();
        printTemp();
        printBaro();
        BaroDiagram();                     // График
        myGLCD.update();
        timer01 = 0;                      // Обнулить таймер01
    }
  //  myGLCD.printNumI(timer01, 1, 16);       
}


void BaroDiagram() {
    /*
    длинна от 38 - 84 пикселя
    высота от 0 - 14 пикселя
    */
    
  float temp(NAN), hum(NAN), pres(NAN);
  uint8_t pressureUnit(0); // unit: B000 = Pa, B001 = hPa, B010 = Hg, B011 = atm, B100 = bar, B101 = torr, B110 = N/m^2, B111 = psi

  pres = Pressure;
  //pres = random (95000,110000); // debug
    
  pres /= 133.3; // convert to mmHg

  avrg.pres += pres;
  avrg.counter++;

    if (avrg.counter >= STORAGE_TIME) {
      pres = avrg.pres / avrg.counter;
      avrg.pres = 0;
      avrg.counter = 0;
     for (int i = 1; i < PLOT_LEN; i++) {
         infoArr[i - 1] = infoArr[i];
    }
    infoArr[PLOT_LEN - 1].pres = round(pres * 2) - 1380;
  }
  
    byte minPres = 255;
    byte maxPres = 0;

    for (int i = PLOT_LEN - 1; i >= 0 ; i--) {
      if (infoArr[i].pres == 0) break;
      if (infoArr[i].pres < minPres) minPres = infoArr[i].pres;
      if (infoArr[i].pres > maxPres) maxPres = infoArr[i].pres;
    }
    if (maxPres - minPres < 10) maxPres = minPres + 10;

//    int z = 0; // для деление графика на столбики 
    int x = 38;
    for (int i = 0; i < PLOT_LEN; i++) {
      if (infoArr[i].pres == 0) continue;
      
      drawCol(x, map(infoArr[i].pres, minPres, maxPres, 14, 0), 14);     //рисуем г-к давление
      
 /*     
  // деление графика на столбики      
  z++;
      if (z > 15) {z = 0; x++;} 
  */    
      x++;
    }    
  }

inline void drawCol(int x, int y, int yn) {
  for (int i = y; i <= yn; i++) {
    myGLCD.setPixel(x, i);
  }
}




